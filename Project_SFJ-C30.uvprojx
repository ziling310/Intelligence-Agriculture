# Keil uVision project Project_SFJ-C30.uvprojx, settings and files
target STM32F030xC (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F030RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: STM32F030xC
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030xC,USE_DEFAULT_TIMEOUT_CALLBACK
  c misc: --C99
  c include: ..\;..\..\00 Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\00 Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\00 Libraries\STM32F0xx_CPAL_Driver\inc;..\..\00 Libraries\CMSIS\Include;.\System;.\Code;.\Uart;.\Communication
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group CMSIS
    ./System/: system_stm32f0xx.c stm32f0xx_it.c startup_stm32f030xc.s
  group User_C
    ./: readme.txt
    ./Code/: main.c stm32_system_timer.c stm32_adc_dac.c gpio_led_buz.c gpio_out.c gpio_in.c Sensor.c algorithm.c DEF.h stm32_system_timer.h stm32_adc_dac.h gpio_in.h gpio_out.h Sensor.h algorithm.h
  group Uart
    ./Uart/: uart_485_command.c uart_lcd_command.c uart_set_command.c stm32_uart_driver.c modbus.c uart_485_command.h uart_lcd_command.h uart_set_command.h stm32_uart_drive.h modbus.h
  group Communication
    ./Communication/: CM_APP.c CM_command.c CM_drive.c CM_APP.h CM_drive.h
  group StdPeriph_Driver_C
    ../../00 Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group StdPeriph_Driver_H
    ../../00 Libraries/STM32F0xx_StdPeriph_Driver/inc/: stm32f0xx_adc.h stm32f0xx_can.h stm32f0xx_cec.h stm32f0xx_comp.h stm32f0xx_crc.h stm32f0xx_crs.h stm32f0xx_dac.h stm32f0xx_dbgmcu.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_i2c.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx_wwdg.h
